** sch_path: xschem/untitled.sch
**.subckt untitled p1 p2
*.iopin p1
*.iopin p2
L1 p1 p2 5.092n m=3
C1 p1 p2 828.74f m=1
**.ends
.end
